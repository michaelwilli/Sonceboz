# Keil uVision project NucleoF446RE_Sonceboz_Motion_Controll.uvprojx, settings and files
target NucleoF446RE (5060528::V5.06 update 5 (build 528)::ARMCC)
  device: STM32F446RETx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.11.0
  cpu: IROM(0x08000000,0x80000) IRAM(0x20000000,0x20000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: NucleoF446RE_Empty
  c flags: Optim=1
  c define: USE_STDPERIPH_DRIVER,STM32F446xx
  c include: ..\Inc;..\..\..\Common_Files;..\..\..\STM32F4xx_StdPeriph_Lib\Libraries\STM32F4xx_StdPeriph_Driver\inc;..\..\..\STM32F4xx_StdPeriph_Lib\Libraries\CMSIS\Device\ST\STM32F4xx\Include;..\..\..\Common_Files\Display
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x20000
  group User
    ../Src/: main.c stm32f4xx_it.c
    ../../../Common_Files/Display/: NucleoF446_LCD.c
  group StdPeriph Lib
    ../../../STM32F4xx_StdPeriph_Lib/Libraries/STM32F4xx_StdPeriph_Driver/src/: stm32f4xx_cryp_des.c stm32f4xx_cryp_tdes.c stm32f4xx_dac.c stm32f4xx_dbgmcu.c stm32f4xx_dcmi.c stm32f4xx_dma.c stm32f4xx_exti.c stm32f4xx_flash.c stm32f4xx_gpio.c stm32f4xx_hash.c stm32f4xx_hash_md5.c stm32f4xx_hash_sha1.c stm32f4xx_i2c.c stm32f4xx_iwdg.c stm32f4xx_pwr.c stm32f4xx_rcc.c stm32f4xx_rng.c stm32f4xx_rtc.c stm32f4xx_sdio.c stm32f4xx_spi.c stm32f4xx_syscfg.c stm32f4xx_tim.c stm32f4xx_usart.c stm32f4xx_wwdg.c misc.c stm32f4xx_adc.c stm32f4xx_can.c stm32f4xx_cec.c stm32f4xx_crc.c stm32f4xx_cryp.c stm32f4xx_cryp_aes.c stm32f4xx_dfsdm.c stm32f4xx_dma2d.c stm32f4xx_dsi.c stm32f4xx_flash_ramfunc.c stm32f4xx_fmc.c stm32f4xx_fmpi2c.c stm32f4xx_lptim.c stm32f4xx_ltdc.c stm32f4xx_qspi.c stm32f4xx_sai.c stm32f4xx_spdifrx.c
software components: CMSIS:CORE 5.0.1, Device:Startup 2.6.0
